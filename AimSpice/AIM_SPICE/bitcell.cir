[aimspice]
[description]
763
Bitcell
.include 90_nm_gpdk\gpdk90nm_ff.cir
.include nor_gate3.cir
.include nor_gate.cir
.include not_gate.cir
.include switch.cir
.include sr_latch.cir

vinInp 3 0 dc 0 pulse(0 1 0ns 5ns 5ns 20ns 40ns)
vinWoR 2 0 dc 0 pulse(0 1 20ns 5ns 5ns 40ns 80ns)
vinSel 1 0 dc 0 pulse(0 1 0ns 5ns 5ns 160ns 320ns)
vdd  6 0 dc 1

* inverted select signal  1 - VIN 2 - VOUT  3 - VDD
xnot1 1 4 6 not_gate
*inverted input signal
xnot2 3 5 6 not_gate

* NOR gate for R 1 - Input A 2 - Input B 3 - Input C 4 - VDD 5 - Output
xnor1 4 2 3 6 7 nor_gate3
* NOR gate for S
xnor2 4 2 5 6 8 nor_gate3

* SR Latch  R S VDD Q NQ
xlatch1 7 8 6 9 10 sr_latch

* Switch  1 - input 2 - Output  3 - control 4 - Not control 5 - vdd
xswitch 9 11 1 4 6 switch
[tran]
0.1
320ns
X
X
0
[ana]
4 1
0
1 1
1 1 -0.5 1.5
4
v(3)
v(2)
v(1)
v(11)
[end]
